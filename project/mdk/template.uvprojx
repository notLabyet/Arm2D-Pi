# Keil uVision project template.uvprojx, settings and files
target AC6-flash (6180000::V6.18::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  BeforeMake: $Stools\pio_all.bat
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USING_RP2040_PWM,PICO_RP2040_USB_DEVICE_UFRAME_FIX=0,PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1,PICO_TIME_DEFAULT_ALARM_POOL_DISABLED=1,TUFTY2040_STATIC_USB_IRQ_HANDLER=1
  c misc: -include "app_cfg.h"
  c include: .;..\..\deivers;..\..\application;..\..\lib\tinyusb\src;..\..\lib\tinyusb\src\portable\raspberrypi\rp2040;..\..\lib\pico_fix\rp2040_usb_device_enumeration\include;..\..\middleware\fatfs_sd\include;..\..\middleware\fatfs_sd\ff15\source;..\..\middleware\fatfs_sd\sd_driver;..\..\middleware\fatfs_sd\sd_driver\SDIO;..\..\middleware\fatfs_sd\sd_driver\SPI;..\..\middleware\fatfs_sd\port
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm include: ..\..\pico-sdk\src\rp2040\hardware_regs\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\pico_platform\include;..\..\pico-sdk\src\common\pico_base\include;.\wrapper\pico_base;..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude;..\..\pico-sdk\src\rp2_common\boot_stage2\include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329
  group Application
    ../../: main.c
    ./: app_cfg.h arm_2d_scene_histogram.c arm_2d_scene_meter.c arm_2d_scene_bubble_charging.c necogirl_dance.c
    ../../application/: qmi8658c_task.c bm8563_task.c usb_descriptors.c usb_mouse.c usb_msc_sd.c usb_debug.c tufty_sdcard.c arm_loader_io_fatfs.c arm_loader_io_fatfs.h tufty_qoi_scene.c tufty_qoi_scene.h
  group platform
    ../../platform/: platform.h platform.c st77xx_parallel_stream.pio.h st7789_simple.c st7789_simple.h st77xx_parallel_byte.pio.h
  group drivers
    ../../deivers/: drv_QMI8658.c bm8563.c
  group TinyUSB
    ../../lib/tinyusb/src/: tusb.c
    ../../lib/tinyusb/src/common/: tusb_fifo.c
    ../../lib/tinyusb/src/device/: usbd.c usbd_control.c
    ../../lib/tinyusb/src/class/hid/: hid_device.c
    ../../lib/tinyusb/src/class/msc/: msc_device.c
    ../../lib/tinyusb/src/portable/raspberrypi/rp2040/: dcd_rp2040.c rp2040_usb.c
    ../../lib/pico_fix/rp2040_usb_device_enumeration/: rp2040_usb_device_enumeration.c
  group FatFs_SDIO
    ../../middleware/fatfs_sd/ff15/source/: ff.c ffsystem.c ffunicode.c
    ../../middleware/fatfs_sd/src/: glue.c f_util.c crc.c my_debug.c util.c
    ../../middleware/fatfs_sd/sd_driver/: dma_interrupts.c sd_card.c sd_timeouts.c
    ../../middleware/fatfs_sd/sd_driver/SDIO/: rp2040_sdio.c sd_card_sdio.c
    ../../middleware/fatfs_sd/sd_driver/SPI/: my_spi.c sd_card_spi.c sd_spi.c
    ../../middleware/fatfs_sd/port/: hw_config.c tufty_sdcard_config.h
software components: Acceleration:Arm-2D Demos:Virtual Resources 2.0.0, Acceleration:Arm-2D Demos:Warped Dial 1.2.1, Acceleration:Arm-2D Extras:Controls 2.16.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.2, Acceleration:Arm-2D Extras:Loaders 5.6.6, Acceleration:Arm-2D Helper:Display Adapter 4.4.3, Acceleration:Arm-2D Helper:PFB 3.2.9, Acceleration:Arm-2D Render Test:Large LMSK 1.4.1, Acceleration:Arm-2D Render Test:Lossless Compressed Mask(LMSK) 1.0.2, Acceleration:Arm-2D:Alpha-Blending 1.2.5, Acceleration:Arm-2D:Core 1.2.5, Acceleration:Arm-2D:Filter 1.2.5, Acceleration:Arm-2D:Transform 1.2.5, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Language Extension:Coroutine 1.0.0, Utilities:perf_counter:Core 2.5.5-dev, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0
