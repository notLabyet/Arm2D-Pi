# Keil uVision project template.uvprojx, settings and files
target AC6-flash (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USING_RP2040_PWM,PICO_FLASH_SIZE_BYTES=33554432,PICO_RP2040_USB_DEVICE_UFRAME_FIX=0,PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1,PICO_TIME_DEFAULT_ALARM_POOL_DISABLED=1,RP2040_STATIC_USB_IRQ_HANDLER=1
  c include: .;..\..\deivers;..\..\application;..\..\platform;./eeProject/GuiUser;./eeProject/GuiUser/fonts;./eeProject/GuiUser/images;./eeProject/GuiUser/output
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm misc: -include "RTE/Device/RP2040_Core0/boot2_config.h"
  asm include: ..\..\pico-sdk\src\rp2040\hardware_regs\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\pico_platform\include;..\..\pico-sdk\src\common\pico_base\include;.\wrapper\pico_base;..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude;..\..\pico-sdk\src\rp2_common\boot_stage2\include
  memory RVCT4: ROM 0x10000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329
  group Application
    ../../: main.c
  group platform
    ../../platform/: pi_platform.h pi_platform.c st7789_simple.c st7789_simple.h
  group GuiUser
    ./eeProject/GuiUser/: home.c homeLogic.c page1.c page1Logic.c
  group GuiUser/fonts
    ./eeProject/GuiUser/fonts/: SimSun_9.c Source_Han_Sans_SC_Normal_16.c Source_Han_Sans_SC_Normal_22.c
  group GuiUser/images
    ./eeProject/GuiUser/images/: calendar_64.c clock_64.c management_64.c schedule_64.c
software components: Acceleration:Arm-2D Extras:Controls 2.16.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.2, Acceleration:Arm-2D Helper:PFB 3.2.9, Acceleration:Arm-2D:Alpha-Blending 1.2.6, Acceleration:Arm-2D:Core 1.2.6, Acceleration:Arm-2D:Filter 1.2.6, Acceleration:Arm-2D:Transform 1.2.6, CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0, Utilities:perf_counter:Core 2.5.5-dev, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0, LingDongGui:ldgui 0.9.0
